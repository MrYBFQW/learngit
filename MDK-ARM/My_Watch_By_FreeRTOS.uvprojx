# Keil uVision project My_Watch_By_FreeRTOS.uvprojx, settings and files
target My_Watch_By_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: My_Watch_By_FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./HardWare;./FreeRTOS/include;./FreeRTOS/src;./My_Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group FreeRTOS
    ./FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ./FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group OLED
    ./HardWare/: oled.h oled.c oledfont.c oledfont.h
  group My_Task
    ./My_Task/: Time_Task.c Time_Task.h Open_Task.c Open_Task.h Menu_Task.c Menu_Task.h Temperature_Task.c Temperature_Task.h Information_Task.c Information_Task.h FlashLight_Task.c FlashLight_Task.h Calendar_Task.c Calendar_Task.h Stopwatch_Task.c Stopwatch_Task.h Heart_Task.c Heart_Task.h Clock_Task.c Clock_Task.h SetSystemTime_Task.c SetSystemTime_Task.h Enter_StopMode_Task.c Enter_StopMode_Task.h Exit_StopMode_Task.c Exit_StopMode_Task.h
  group Application/User/Core
    ../Core/Src/: FreeRTOSInit.c main.c gpio.c adc.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
    ../Core/Inc/: FreeRTOSInit.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group DS18B20
    ./HardWare/: ds18b20.c ds18b20.h
  group buzzer
    ./HardWare/: buzzer.c buzzer.h
  group delay
    ./HardWare/: delay.c delay.h
  group ds1302
    ./HardWare/: ds1302.c ds1302.h
software components: CMSIS:CORE 4.3.0
